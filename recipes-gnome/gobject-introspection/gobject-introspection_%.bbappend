# DEPENDS += "python3-setuptools-native python3-distutils-native"